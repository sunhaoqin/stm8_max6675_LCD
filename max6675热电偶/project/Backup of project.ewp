# IAR project Backup of project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\STM8L15x_StdPeriph_Driver\inc; ..\user; ..\bsp
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/: bsp_io.c bsp_key.c bsp_lcd.c bsp_low.c bsp_rtc.c bsp_si7005.c bsp_soft_i2c.c bsp_sysclk.c
  group STM8L15x_StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_tim4.c
  group user
    ../user/: main.c stm8l15x_it.c
